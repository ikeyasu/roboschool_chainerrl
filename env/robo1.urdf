Commit message: Add CustomStadiumScene to be bumpy floor.

File: env/robo1.urdf (robot description, URDF)
Before this commit: robot flexible, 13 links, 12 joints
Links:
- link base_link: geometry collision box size=.66 .56 .12; visual box size=.66 .56 .12
